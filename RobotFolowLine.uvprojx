# Keil uVision project RobotFolowLine.uvprojx, settings and files
target RobotFollowLine (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RobotFolowLine +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\MyLib;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
  group MyLib
    ./MyLib/: SysClock.c gpio_driver.c i2c_driver.c timer_driver.c
  group App
    ./App/: lcd_i2c.c motor.c hcsr04.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
